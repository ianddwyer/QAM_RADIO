options:
  parameters:
    author: Eian
    generate_options: qt_gui
    id: untitled
    output_language: python
    realtime_scheduling: '1'
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: delay
  id: variable_qtgui_range
  parameters:
    label: delay
    rangeType: int
    start: '0'
    step: '1'
    stop: '100'
    value: '0'
    widget: counter
  states: {}
- name: device_rate
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_char_0_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_message_debug_1
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_probe_rate_1
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    maxoutbuf: int(2e6)
    mintime: '2000'
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: device_rate*2*4
    type: float
  states: {}
- name: network_udp_sink_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '1024'
    port: '5007'
    send_eof: 'False'
    type: byte
  states: {}
- name: network_udp_source_1_0
  id: network_udp_source
  parameters:
    header: '0'
    ipv6: 'False'
    maxoutbuf: int(2e6)
    notify_missed: 'True'
    payloadsize: '1024'
    port: '5006'
    src_zeros: 'True'
    type: byte
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    label1: TX
    label2: RX
    name: At Port"
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '128'
    ymin: '-128'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '1'
    taps: '1'
    type: fff
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '1'
    taps: '1'
    type: fff
  states: {}

connections:
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_char_to_float_0, '0', rational_resampler_xxx_1, '0']
- [blocks_char_to_float_0_0, '0', blocks_throttle2_0, '0']
- [blocks_float_to_char_0, '0', blocks_char_to_float_0, '0']
- [blocks_float_to_char_0_0, '0', network_udp_sink_0, '0']
- [blocks_probe_rate_1, rate, blocks_message_debug_1, print]
- [blocks_throttle2_0, '0', rational_resampler_xxx_0, '0']
- [network_udp_source_1_0, '0', blocks_char_to_float_0_0, '0']
- [network_udp_source_1_0, '0', blocks_probe_rate_1, '0']
- [rational_resampler_xxx_0, '0', blocks_float_to_char_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_time_sink_x_0, '0']
- [rational_resampler_xxx_1, '0', blocks_float_to_char_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
