options:
  parameters:
    category: Custom
    description: Transmit a pre-defined signal (a complex sine) as OFDM packets.
    generate_options: qt_gui
    id: ofdm_loopback_example
    output_language: python
    realtime_scheduling: '1'
    title: OFDM Loopback Example
  states: {}

blocks:
- name: access_key
  id: variable
  parameters:
    value: '''11100001010110101110100010010011'''
  states: {}
- name: centerf
  id: variable
  parameters:
    value: 912e6
  states: {}
- name: device_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: fft_len
  id: variable
  parameters:
    value: '32'
  states: {}
- name: len_tag_key
  id: variable
  parameters:
    value: '"packet_len"'
  states: {}
- name: ofdm_rate
  id: variable
  parameters:
    value: samp_rate/(fft_len+8)*4
  states: {}
- name: packet_len
  id: variable
  parameters:
    comment: |-
      set to -1 to visually 
      see packets pass
      but should be set
      to whole base-2
    value: 128-1
  states: {}
- name: rxgain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: '"Receive Gain"'
    min_len: '8'
    start: '4'
    step: '1'
    stop: '40'
    value: '4'
    widget: counter
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: success
  id: variable_function_probe
  parameters:
    block_id: successpackets
    function_name: level
    poll_rate: '1000'
    value: '0'
  states: {state: disabled}
- name: txgain
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,1,1,1
    label: '"Transmit Gain"'
    min_len: '8'
    start: '0'
    step: '1'
    stop: '60'
    value: '60'
    widget: counter
  states: {}
- name: variable_qtgui_label_2
  id: variable_qtgui_label
  parameters:
    gui_hint: 0,0,1,1
    label: 'Success Packets: '
    type: real
    value: success
  states: {state: disabled}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: int(device_rate)
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_correctiq_auto_0
  id: blocks_correctiq_auto
  parameters:
    freq: centerf
    gain: '1'
    samp_rate: samp_rate
    syncWindow: '2'
  states: {}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    file: successpktcount.bin
    type: float
  states: {state: disabled}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '127'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/127
    type: float
  states: {}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '500.0'
    name: rate
    type: float
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: len_tag_key
    packet_len: packet_len
    type: byte
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    display: 'False'
    name: Rx Packets
    type: byte
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '1'
    init: '0'
    low: '0'
  states: {state: disabled}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: device_rate
    type: float
  states: {state: bypassed}
- name: blocks_throttle2_1
  id: blocks_throttle2
  parameters:
    samples_per_second: device_rate
    type: float
  states: {state: bypassed}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: '"music/Not In My Arms (Calibeats Remix)  Takara.mp3"'
    maxoutbuf: int(2e6)
    repeat: 'True'
  states: {}
- name: digital_ofdm_rx_0
  id: digital_ofdm_rx
  parameters:
    cp_len: fft_len//4
    fft_len: fft_len
    header_mod: '"BPSK"'
    maxoutbuf: '200000'
    occupied_carriers: ((-4,-3,-2,-1,1,2,3,4),)
    packet_len_key: '"rx_len"'
    payload_mod: '"QPSK"'
    pilot_carriers: ((-6,-5,5,6),)
    pilot_symbols: ((-1,1,-1,1),)
    sync_word1: None
    sync_word2: None
  states: {}
- name: digital_ofdm_tx_0
  id: digital_ofdm_tx
  parameters:
    cp_len: fft_len//4
    fft_len: fft_len
    header_mod: '"BPSK"'
    maxoutbuf: '200000'
    occupied_carriers: ((-4,-3,-2,-1,1,2,3,4),)
    packet_len_key: len_tag_key
    payload_mod: '"QPSK"'
    pilot_carriers: ((-6,-5,5,6),)
    pilot_symbols: ((-1,1,-1,1),)
    rolloff: '0'
    sync_word1: None
    sync_word2: None
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      # -*- coding: utf-8 -*-
      """
      Created on Tue Apr 15 02:21:22 2025

      @author: Eian
      """

      import numpy
      from gnuradio import gr

      class tag_counter_block(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(
                  self, 
                  name="Tag Counter",
                  in_sig=[numpy.float32], 
                  out_sig=[numpy.float32])
              self.tag_count = 0

          def work(self, input_items, output_items):
              
              tags = self.get_tags_in_window(0, 0, len(input_items[0]))# Get tags in the current work call
              self.tag_count += len(tags)# Count the tags
              output_items[0][:] = self.tag_count # Pass data through
              return len(output_items[0]) #return length of output for tag ref
    maxoutbuf: int(2e6)
  states: {state: disabled}
- name: mmse_resampler_xx_2
  id: mmse_resampler_xx
  parameters:
    maxoutbuf: int(2e6)
    phase_shift: '0'
    resamp_ratio: samp_rate/ofdm_rate
    type: float
  states: {}
- name: mmse_resampler_xx_2_0
  id: mmse_resampler_xx
  parameters:
    maxoutbuf: int(2e6)
    phase_shift: '0'
    resamp_ratio: ofdm_rate/samp_rate
    type: float
  states: {}
- name: packetgen_0
  id: packetgen
  parameters:
    access_key: access_key
    comment: |-
      Create packet with header
      for tracking
    maxoutbuf: int(2e6)
    packet_len: packet_len
    packet_len_tagn: '"packet_len"'
  states: {state: disabled}
- name: packetread_0
  id: packetread
  parameters:
    access_key: access_key
    maxoutbuf: int(2e6)
    packet_len: packet_len
    packet_len_tagn: '"packet_len"'
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    label1: Rx Spectrum
    label2: ''
    name: Rx Spectrum
    nconnections: '2'
    showports: 'True'
    type: complex
    ymax: '-20'
    ymin: '-70'
  states: {}
- name: rx_start_flag
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {state: disabled}
- name: satellites_rms_agc_0
  id: satellites_rms_agc
  parameters:
    alpha: '0.000001'
    reference: '0.707'
  states: {}
- name: satellites_rms_agc_1
  id: satellites_rms_agc
  parameters:
    alpha: '0.000001'
    reference: '0.707'
  states: {}
- name: successpackets
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {state: disabled}
- name: uhd_usrp_sink_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: centerf
    dev_args: '"serial=UF7ENUJ"'
    gain0: txgain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    center_freq0: centerf
    dev_args: '"serial=15YWBBW"'
    gain0: rxgain
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [blocks_char_to_float_0, '0', epy_block_0, '0']
- [blocks_char_to_float_0, '0', mmse_resampler_xx_2_0, '0']
- [blocks_correctiq_auto_0, '0', digital_ofdm_rx_0, '0']
- [blocks_correctiq_auto_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_float_to_char_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_float_to_char_0, '0', packetgen_0, '0']
- [blocks_multiply_const_vxx_0, '0', mmse_resampler_xx_2, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_throttle2_0, '0']
- [blocks_probe_rate_0, rate, blocks_message_debug_0, print]
- [blocks_stream_to_tagged_stream_0, '0', digital_ofdm_tx_0, '0']
- [blocks_threshold_ff_0, '0', rx_start_flag, '0']
- [blocks_throttle2_0, '0', audio_sink_0, '0']
- [blocks_throttle2_1, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_wavfile_source_0, '0', blocks_throttle2_1, '0']
- [digital_ofdm_rx_0, '0', blocks_char_to_float_0, '0']
- [digital_ofdm_rx_0, '0', blocks_tag_debug_0, '0']
- [digital_ofdm_rx_0, '0', packetread_0, '0']
- [digital_ofdm_tx_0, '0', satellites_rms_agc_1, '0']
- [epy_block_0, '0', blocks_file_sink_0_0_0, '0']
- [epy_block_0, '0', blocks_threshold_ff_0, '0']
- [epy_block_0, '0', successpackets, '0']
- [mmse_resampler_xx_2, '0', blocks_float_to_char_0, '0']
- [mmse_resampler_xx_2_0, '0', blocks_multiply_const_vxx_1, '0']
- [mmse_resampler_xx_2_0, '0', blocks_probe_rate_0, '0']
- [packetgen_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [packetread_0, '0', blocks_char_to_float_0, '0']
- [satellites_rms_agc_0, '0', blocks_correctiq_auto_0, '0']
- [satellites_rms_agc_1, '0', qtgui_freq_sink_x_0, '1']
- [satellites_rms_agc_1, '0', uhd_usrp_sink_0_0, '0']
- [uhd_usrp_source_0_0, '0', satellites_rms_agc_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
