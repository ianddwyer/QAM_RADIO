options:
  parameters:
    generate_options: hb
    id: print_pkt
    output_language: python
    title: Print Filled Unicode Pkt
  states: {}

blocks:
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: "\nimport numpy as np\nfrom gnuradio import gr\nimport pmt\n\nclass DropByteToMessage(gr.basic_block):\n    def __init__(self, dropvalue=0xFF):\n        gr.basic_block.__init__(\n            self,\n            name=\"Drop Null\",\n            in_sig=[np.uint8],   # Stream input (bytes)\n            out_sig=None         # Message output init will null\n        )\n        self.message_port_register_out(pmt.intern(\"out\"))  # Create message output port\n\n    def general_work(self, input_items, output_items):\n        # Filter out the unwanted byte\n        filtereddata = [x for x in input_items[0] if x != 0]\n        \n        if filtereddata:  # If there's valid data after filtering\n            msg = pmt.init_u8vector(len(filtereddata), filtereddata)  # Convert to PMT message\n            self.message_port_pub(pmt.intern(\"out\"), msg)  # Send the message\n        \n        self.consume(0, len(input_items[0]))  # Consume all input samples\n        return 0  # No output samples in streaming mode (only messages), not a standard zero return\n"
    dropvalue: '0'
  states: {}
- name: epy_block_3
  id: epy_block
  parameters:
    _source_code: |
      from gnuradio import gr
      import pmt

      class PMTByteArrayToString(gr.basic_block):
          def __init__(self):
              gr.basic_block.__init__(
                  self,
                  name="Bytes to String",
                  in_sig=None, out_sig=None
              )

              # Register input and output message ports
              self.message_port_register_in(pmt.intern("in"))
              self.message_port_register_out(pmt.intern("out"))
              self.set_msg_handler(pmt.intern("in"), self.handle_msg)

          def handle_msg(self, msg):

              # ensure the input is a PMT byte vector, not a PDU
              if not pmt.is_u8vector(msg): return

              # convert PMT byte vector to a Python byte array
              byte_array = bytearray(pmt.u8vector_elements(msg))

              # convert bytes to string (UTF-8 decoding), use try for safety in live streaming
              try:string_message = byte_array.decode("utf-8")
              except UnicodeDecodeError: string_message = byte_array.decode("ISO-8859-1")  # Fallback use ISO format for compatibility

              # publish the string as a PMT symbol (message)
              self.message_port_pub(pmt.intern("out"), pmt.intern(string_message))
  states: {}
- name: epy_block_4
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt
      import sys  

      class print_message_block(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(self,
                  name="Print to Console",
                  in_sig=None,
                  out_sig=None)  # No output signal needed

              # register message input port
              self.message_port_register_in(pmt.intern('msg_in'))
              self.set_msg_handler(pmt.intern('msg_in'), self.handle_msg)

          def handle_msg(self, msg):
              text = pmt.symbol_to_string(msg)  # convert PMT to string
              print(f"RX: {text}")
              sys.stdout.flush()  # pnsure immediate print output on load, else is unreliable timing
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: byte
  states: {}

connections:
- [epy_block_1, out, epy_block_3, in]
- [epy_block_3, out, epy_block_4, msg_in]
- [pad_source_0, '0', epy_block_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
