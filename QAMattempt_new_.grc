options:
  parameters:
    generate_options: qt_gui
    id: QAMattempt
    output_language: python
    realtime_scheduling: '1'
    title: QAM
  states: {}

blocks:
- name: C
  id: variable
  parameters:
    value: qam16
  states: {}
- name: aa
  id: variable_adaptive_algorithm
  parameters:
    cons: C
    modulus: C.arity()
    step_size: '0.00005'
    type: cma
  states: {}
- name: access_key
  id: variable
  parameters:
    value: '''11100001010110101110100010010011'''
  states: {}
- name: allpack
  id: variable_function_probe
  parameters:
    block_id: allpackets
    function_name: level
    poll_rate: '1000'
    value: '0'
  states: {}
- name: bandwidth
  id: variable
  parameters:
    value: symbol_rate*(1+exbw)
  states: {}
- name: centerf
  id: variable
  parameters:
    value: 0.912e9
  states: {}
- name: device_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: exbw
  id: variable
  parameters:
    value: '0.75'
  states: {}
- name: final_breath
  id: variable
  parameters:
    value: '"Final+Breath.wav"'
  states: {}
- name: hdr_format
  id: variable
  parameters:
    comment: header_format_default
    value: digital.header_format_default(access_key, 0)
  states: {}
- name: hunter
  id: variable
  parameters:
    value: '"Subtronics x Flowdan - Hunter.wav"'
  states: {}
- name: inputtype_sel
  id: variable
  parameters:
    value: music
  states: {}
- name: message
  id: variable
  parameters:
    value: '0'
  states: {}
- name: modulated_sync_word
  id: variable_modulate_vector
  parameters:
    data: '[225, 90, 232, 147, 1, 0, 1, 0]'
    mod: rxmod
    taps: '[1]'
  states: {}
- name: music
  id: variable
  parameters:
    value: '1'
  states: {}
- name: next_episode
  id: variable
  parameters:
    value: '"Dr. Dre - The Next Episode (Wooli Flip).wav"'
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: port
  id: variable
  parameters:
    value: '5005'
  states: {}
- name: ppm
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1,1,1
    label: '"Tune PPM"'
    min_len: 20*10
    start: '-10'
    step: '0.1'
    stop: '10'
    value: '0.3'
    widget: counter
  states: {}
- name: psk2
  id: variable_constellation
  parameters:
    const_points: np.array([-1, 1])
    dims: '1'
    normalization: digital.constellation.NO_NORMALIZATION
    npwr: '2'
    precision: '16'
    rot_sym: '4'
    sym_map: '[0, 1]'
    type: calcdist
  states: {}
- name: psk4
  id: variable_constellation
  parameters:
    const_points: np.array([-4-4j, -4+4j, 4+4j, 4-4j])/4
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    npwr: '2'
    precision: '16'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    type: calcdist
  states: {}
- name: psk8
  id: variable_constellation
  parameters:
    const_points: np.array([-0.75+0.75j,-0.25-0.75j,0.75-0.75j, 0.25-0.75j,0.75-0.25j, 0.25-0.25j, -0.75-0.25j, -0.25-0.25j, 0.75+0.75j, 0.25+0.75j, -0.75-0.75j, -0.25+0.75j, -0.75+0.25j,-0.25+0.25j, 0.75+0.25j, 0.25+0.25j])/0.75
    npwr: '2'
    precision: '16'
    sym_map: list(range(16))
    type: 8psk
  states: {}
- name: qam16
  id: variable_constellation
  parameters:
    const_points: np.array([-0.75+0.75j,-0.25-0.75j,0.75-0.75j, 0.25-0.75j,0.75-0.25j, 0.25-0.25j, -0.75-0.25j, -0.25-0.25j, 0.75+0.75j, 0.25+0.75j, -0.75-0.75j, -0.25+0.75j, -0.75+0.25j,-0.25+0.25j, 0.75+0.25j, 0.25+0.25j])
    normalization: digital.constellation.NO_NORMALIZATION
    npwr: '2'
    precision: '16'
    sym_map: list(range(16))
    type: 16qam
  states: {}
- name: qam64
  id: variable_constellation
  parameters:
    const_points: np.array([-0.70711+-0.70711j, -0.50508+-0.70711j, -0.30304+-0.70711j, -0.10101+-0.70711j, 0.10101+-0.70711j, 0.30304+-0.70711j, 0.50508+-0.70711j, 0.70711+-0.70711j, -0.70711+-0.50508j, -0.50508+-0.50508j, -0.30304+-0.50508j, -0.10101+-0.50508j, 0.10101+-0.50508j, 0.30304+-0.50508j, 0.50508+-0.50508j, 0.70711+-0.50508j, -0.70711+-0.30304j, -0.50508+-0.30304j, -0.30304+-0.30304j, -0.10101+-0.30304j, 0.10101+-0.30304j, 0.30304+-0.30304j, 0.50508+-0.30304j, 0.70711+-0.30304j, -0.70711+-0.10101j, -0.50508+-0.10101j, -0.30304+-0.10101j, -0.10101+-0.10101j, 0.10101+-0.10101j, 0.30304+-0.10101j, 0.50508+-0.10101j, 0.70711+-0.10101j, -0.70711+0.10101j, -0.50508+0.10101j, -0.30304+0.10101j, -0.10101+0.10101j, 0.10101+0.10101j, 0.30304+0.10101j, 0.50508+0.10101j, 0.70711+0.10101j, -0.70711+0.30304j, -0.50508+0.30304j, -0.30304+0.30304j, -0.10101+0.30304j, 0.10101+0.30304j, 0.30304+0.30304j, 0.50508+0.30304j, 0.70711+0.30304j, -0.70711+0.50508j, -0.50508+0.50508j, -0.30304+0.50508j, -0.10101+0.50508j, 0.10101+0.50508j, 0.30304+0.50508j, 0.50508+0.50508j, 0.70711+0.50508j, -0.70711+0.70711j, -0.50508+0.70711j, -0.30304+0.70711j, -0.10101+0.70711j, 0.10101+0.70711j, 0.30304+0.70711j, 0.50508+0.70711j, 0.70711+0.70711j])/0.70711
    dims: '1'
    normalization: digital.constellation.NO_NORMALIZATION
    npwr: '2'
    precision: '16'
    rot_sym: '4'
    sym_map: list(range(64))
    type: calcdist
  states: {}
- name: qam8
  id: variable_constellation
  parameters:
    const_points: np.array([-1-1j, -1+1j, 1+1j, 1-1j, -0.67j, 0.67, 0.67j, -0.67])
    dims: '1'
    normalization: digital.constellation.NO_NORMALIZATION
    npwr: '2'
    precision: '16'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3, 4, 5 ,6 ,7]'
    type: calcdist
  states: {}
- name: random
  id: variable
  parameters:
    value: '2'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(128, 128, 1.0/float(samp_per_sym), exbw, 11*samp_per_sym*128)
  states: {}
- name: rxgain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: '"Receive Gain"'
    min_len: '8'
    start: '7'
    step: '1'
    stop: '40'
    value: '20'
    widget: counter
  states: {}
- name: rxmod
  id: variable
  parameters:
    value: digital.generic_mod(C, True, samp_per_sym, True, exbw, False, False)
  states: {}
- name: rxstartflag
  id: variable_function_probe
  parameters:
    block_id: rx_start_flag
    function_name: level
    poll_rate: '1000'
    value: '0'
  states: {}
- name: samp_per_sym
  id: variable
  parameters:
    value: '24'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: shift
  id: variable
  parameters:
    value: samp_rate/4
  states: {}
- name: success
  id: variable_function_probe
  parameters:
    block_id: successpackets
    function_name: level
    poll_rate: '1000'
    value: '0'
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: samp_rate/samp_per_sym
  states: {}
- name: txgain
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,1,1,1
    label: '"Transmit Gain"'
    min_len: '8'
    start: '0'
    step: '1'
    stop: '60'
    value: '60'
    widget: counter
  states: {}
- name: umm
  id: variable
  parameters:
    value: '"I Don''t Know.wav"'
  states: {}
- name: variable_qtgui_label_1
  id: variable_qtgui_label
  parameters:
    gui_hint: 1,0,1,1
    label: 'Total Packets: '
    type: real
    value: allpack
  states: {}
- name: variable_qtgui_label_2
  id: variable_qtgui_label
  parameters:
    gui_hint: 0,0,1,1
    label: 'Success Packets: '
    type: real
    value: success
  states: {}
- name: allpackets
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '255'
    min: '0'
    num_samps: packet_len
    repeat: 'True'
    type: byte
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: int(device_rate)
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_7
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_7_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_correctiq_0
  id: blocks_correctiq
  parameters:
    maxoutbuf: int(2e6)
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: totalpktcount.bin
    type: float
  states: {}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    file: successpktcount.bin
    type: float
  states: {}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_freqshift_cc_0
  id: blocks_freqshift_cc
  parameters:
    freq: shift
    sample_rate: samp_rate
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_1
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 127*0.5
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/127
    type: float
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: '0.5'
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_null_sink_1_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_null_sink_1_1
  id: blocks_null_sink
  parameters:
    num_inputs: '3'
    type: float
  states: {}
- name: blocks_null_sink_1_1_0
  id: blocks_null_sink
  parameters:
    num_inputs: '3'
    type: float
  states: {}
- name: blocks_null_sink_2
  id: blocks_null_sink
  parameters:
    type: byte
  states: {state: disabled}
- name: blocks_null_sink_3
  id: blocks_null_sink
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_null_sink_4
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_probe_rate_1
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    maxoutbuf: int(2e6)
    mintime: '2000'
    type: float
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    maxoutbuf: int(2e6)
    num_inputs: '1'
    num_outputs: '3'
    output_index: inputtype_sel
    type: byte
  states: {}
- name: blocks_selector_0_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: inputtype_sel
    num_inputs: '3'
    num_outputs: '1'
    output_index: '0'
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_1
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: (packet_len+12)*4
    type: complex
  states: {state: disabled}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '1'
    init: '0'
    low: '0'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    ignoretag: 'False'
    maxoutbuf: int(2e6)
    samples_per_second: device_rate
    type: float
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    ignoretag: 'False'
    maxoutbuf: int(2e6)
    samples_per_second: device_rate
    type: float
  states: {}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: C.bits_per_symbol()
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: packet_len
    type: float
  states: {state: disabled}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: '"music/Not In My Arms (Calibeats Remix)  Takara.mp3"'
    maxoutbuf: int(2e6)
    repeat: 'True'
  states: {}
- name: const_demod_0
  id: const_demod
  parameters:
    C: C
    agc_attack: '0.001'
    agc_decay: '0.001'
    agc_ref: '0.95'
    arity: C.arity()
    bits_per_symbol: C.bits_per_symbol()
    const_slicer: C.base()
    exbw: exbw
    loop_bw: samp_rate/centerf*abs(ppm)
    max_freq_dev: abs(ppm)*samp_rate/centerf*8
    maxoutbuf: int(2e6)
    min_freq_dev: '-abs(ppm)*samp_rate/centerf*8'
    nfilt: '512'
    samp_per_sym: samp_per_sym
    step_sz: '0'
    swidx: int(np.floor(C.arity()/16))
    ted_gain: '0.01'
    timing_bw: samp_rate/centerf*abs(ppm)/10
    timing_damping: '0.707'
  states: {state: disabled}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    comment: |-
      RRC pulse shaping
      and modulation in one
    constellation: C
    differential: 'True'
    excess_bw: exbw
    maxoutbuf: int(2e6)
    samples_per_symbol: samp_per_sym
  states: {}
- name: digital_constellation_receiver_cb_0_0
  id: digital_constellation_receiver_cb
  parameters:
    comment: |-
      The receiver is the PLL
      It also acts as the constellation
      decoder
      must have 0 deviation to get large packets
    constellation: C
    fmax: '0'
    fmin: '0'
    loop_bw: 0.0628*0.75
    showports: 'True'
  states: {}
- name: digital_constellation_receiver_cb_0_0_0
  id: digital_constellation_receiver_cb
  parameters:
    comment: |-
      The receiver is the PLL
      It also acts as the constellation
      decoder
      must have 0 deviation to get large packets
    constellation: C
    fmax: '0'
    fmin: '0'
    loop_bw: 0.0628*2
    showports: 'True'
  states: {}
- name: digital_diff_decoder_bb_0_1
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: C.arity()
  states: {}
- name: digital_linear_equalizer_0
  id: digital_linear_equalizer
  parameters:
    alg: aa
    comment: |-
      channel linearization
      stablizes gain and allows
      for following agc to 
      use a more aggressive
      step to further retain
      proper gain values

      be cautious with this block
    num_taps: '1'
    sps: '1'
  states: {}
- name: digital_symbol_sync_xx_0_0
  id: digital_symbol_sync_xx
  parameters:
    comment: Timing sync and demod
    constellation: C.base()
    damping: '0.5'
    loop_bw: samp_rate/centerf*abs(ppm)/100
    max_dev: '0'
    nfilters: '128'
    osps: '1'
    pfb_mf_taps: rrc_taps
    resamp_type: digital.IR_PFB_MF
    sps: samp_per_sym
    ted_gain: '0.00005'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: digital_symbol_sync_xx_0_0_0
  id: digital_symbol_sync_xx
  parameters:
    comment: Timing sync and demod
    constellation: C.base()
    damping: '2'
    loop_bw: samp_rate/centerf*abs(ppm)/100
    max_dev: '0'
    nfilters: '128'
    osps: '1'
    pfb_mf_taps: rrc_taps
    resamp_type: digital.IR_PFB_MF
    sps: samp_per_sym
    ted_gain: '0.01'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      # -*- coding: utf-8 -*-
      """
      Created on Tue Apr 15 02:21:22 2025

      @author: Eian
      """

      import numpy
      from gnuradio import gr

      class tag_counter_block(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(
                  self, 
                  name="Tag Counter",
                  in_sig=[numpy.float32], 
                  out_sig=[numpy.float32])
              self.tag_count = 0

          def work(self, input_items, output_items):
              
              tags = self.get_tags_in_window(0, 0, len(input_items[0]))# Get tags in the current work call
              self.tag_count += len(tags)# Count the tags
              output_items[0][:] = self.tag_count # Pass data through
              return len(output_items[0]) #return length of output for tag ref
    maxoutbuf: int(2e6)
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      # -*- coding: utf-8 -*-
      """
      Created on Tue Apr 15 02:21:22 2025

      @author: Eian
      """

      import numpy
      from gnuradio import gr

      class tag_counter_block(gr.sync_block):
          def __init__(self,rxflag=0):
              gr.sync_block.__init__(
                  self, 
                  name="Tag Counter",
                  in_sig=[numpy.float32], 
                  out_sig=[numpy.float32])
              self.tag_count = 0
              self.rxflag = 0

          def work(self, input_items, output_items):
              
              tags = self.get_tags_in_window(0, 0, len(input_items[0]))# Get tags in the current work call
              self.tag_count += len(tags)*self.rxflag# Count the tags
              output_items[0][:] = self.tag_count # Pass data through
              return len(output_items[0]) #return length of output for tag ref
    maxoutbuf: int(2e6)
    rxflag: rxstartflag
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: "\nimport numpy as np\nfrom gnuradio import gr\nimport pmt\n\nclass DropByteToMessage(gr.basic_block):\n    def __init__(self, dropvalue=0xFF):\n        gr.basic_block.__init__(\n            self,\n            name=\"Drop Null\",\n            in_sig=[np.uint8],   # Stream input (bytes)\n            out_sig=None         # Message output init will null\n        )\n        self.message_port_register_out(pmt.intern(\"out\"))  # Create message output port\n\n    def general_work(self, input_items, output_items):\n        # Filter out the unwanted byte\n        filtereddata = [x for x in input_items[0] if x != 0]\n        \n        if filtereddata:  # If there's valid data after filtering\n            msg = pmt.init_u8vector(len(filtereddata), filtereddata)  # Convert to PMT message\n            self.message_port_pub(pmt.intern(\"out\"), msg)  # Send the message\n        \n        self.consume(0, len(input_items[0]))  # Consume all input samples\n        return 0  # No output samples in streaming mode (only messages), not a standard zero return\n"
    dropvalue: '0'
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name="PrintBytes",         # Block name
                  in_sig=[np.uint8],         # Input stream of bytes
                  out_sig=[]                 # No output
              )

          def work(self, input_items, output_items):
              in0 = input_items[0]

              # Print incoming bytes as list of integers
              print("Received Bytes:", list(in0))

              # Optional: Print as hex
              # print("Hex:", [hex(b) for b in in0])

              return len(in0)
  states: {state: disabled}
- name: epy_block_3
  id: epy_block
  parameters:
    _source_code: |
      from gnuradio import gr
      import pmt

      class PMTByteArrayToString(gr.basic_block):
          def __init__(self):
              gr.basic_block.__init__(
                  self,
                  name="Bytes to String",
                  in_sig=None, out_sig=None
              )

              # Register input and output message ports
              self.message_port_register_in(pmt.intern("in"))
              self.message_port_register_out(pmt.intern("out"))
              self.set_msg_handler(pmt.intern("in"), self.handle_msg)

          def handle_msg(self, msg):

              # ensure the input is a PMT byte vector, not a PDU
              if not pmt.is_u8vector(msg): return

              # convert PMT byte vector to a Python byte array
              byte_array = bytearray(pmt.u8vector_elements(msg))

              # convert bytes to string (UTF-8 decoding), use try for safety in live streaming
              try:string_message = byte_array.decode("utf-8")
              except UnicodeDecodeError: string_message = byte_array.decode("ISO-8859-1")  # Fallback use ISO format for compatibility

              # publish the string as a PMT symbol (message)
              self.message_port_pub(pmt.intern("out"), pmt.intern(string_message))
  states: {}
- name: epy_block_4
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt
      import sys  

      class print_message_block(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(self,
                  name="Print to Console",
                  in_sig=None,
                  out_sig=None)  # No output signal needed

              # register message input port
              self.message_port_register_in(pmt.intern('msg_in'))
              self.set_msg_handler(pmt.intern('msg_in'), self.handle_msg)

          def handle_msg(self, msg):
              text = pmt.symbol_to_string(msg)  # convert PMT to string
              print(f"RX: {text}")
              sys.stdout.flush()  # pnsure immediate print output on load, else is unreliable timing
  states: {}
- name: epy_block_5
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt

      class blk(gr.sync_block):
          def __init__(self, fft_size=1024, avg_frames_base2=64, sample_rate=2e6,
                       symbol_rate=250e3, excess_bw=0.35, report_interval=1):
              gr.sync_block.__init__(
                  self,
                  name='RRC SNR Detector',
                  in_sig=[np.complex64],
                  out_sig=[],
              )

              # Parameters
              self.fft_size = fft_size
              self.step = fft_size // 2  # 50% overlap
              self.avg_frames = avg_frames_base2
              self.sample_rate = sample_rate
              self.symbol_rate = symbol_rate
              self.excess_bw = excess_bw
              self.report_interval = float(report_interval)  # in seconds

              # Auto compute how many samples to skip to hit the desired report interval
              samples_for_avg = self.avg_frames * self.step
              total_samples = int(self.report_interval * self.sample_rate)
              self.skip_samples_after_output = max(0, total_samples - samples_for_avg)

              # Internal state
              self.buffer = np.zeros((self.avg_frames, self.fft_size), dtype=np.complex64)
              self.buffer_index = 0
              self.samples_to_skip = 0
              self.residual = np.array([], dtype=np.complex64)

              # Frequency masks for signal and noise regions
              freqs = np.fft.fftfreq(self.fft_size, d=1.0 / self.sample_rate)
              half_bw = self.symbol_rate / 2
              trans_bw = self.symbol_rate * (1 + self.excess_bw) / 2
              self.signal_mask = np.abs(freqs) <= half_bw
              self.noise_mask = np.abs(freqs) > trans_bw
              self.normalizer_signal = np.count_nonzero(self.signal_mask)
              self.normalizer_noise = np.count_nonzero(self.noise_mask)

              self.message_port_register_out(pmt.intern("snr_out"))

          def work(self, input_items, output_items):
              in0 = np.concatenate((self.residual, input_items[0]))

              # Skip processing if in skip window
              if self.samples_to_skip > 0:
                  to_consume = min(len(in0), self.samples_to_skip)
                  self.samples_to_skip -= to_consume
                  self.residual = in0[to_consume:]
                  return len(input_items[0])

              i = 0
              while i + self.fft_size <= len(in0):
                  window = in0[i:i+self.fft_size]
                  fft_result = np.fft.fftshift(np.fft.fft(window) / np.sqrt(self.fft_size))
                  self.buffer[self.buffer_index % self.avg_frames] = fft_result
                  self.buffer_index += 1
                  i += self.step

                  if self.buffer_index >= self.avg_frames:
                      avg_fft = np.mean(np.abs(self.buffer)**2, axis=0)
                      signal_power = np.sum(avg_fft[self.signal_mask]) / self.normalizer_signal
                      noise_power = np.sum(avg_fft[self.noise_mask]) / self.normalizer_noise
                      snr = signal_power / (noise_power + 1e-12)
                      snr_db = abs(10 * np.log10(snr))

                      msg = pmt.cons(pmt.intern("snr"), pmt.from_double(snr_db))
                      msg_type = pmt.intern("snr_out")
                      self.message_port_pub(msg_type, msg)

                      # Reset buffer and enter skip mode
                      self.buffer_index = 0
                      self.samples_to_skip = self.skip_samples_after_output
                      break  # break loop to enforce skip window

              self.residual = in0[i:]
              return len(input_items[0])
    avg_frames_base2: '64'
    excess_bw: exbw
    fft_size: 1024*4
    maxoutbuf: int(2e6)
    report_interval: '1'
    sample_rate: samp_rate
    symbol_rate: samp_rate/samp_per_sym
  states: {}
- name: epy_block_6
  id: epy_block
  parameters:
    _source_code: |
      import pmt
      from gnuradio import gr
      from datetime import datetime

      class blk(gr.basic_block):
          def __init__(self, filename="output_log.txt"):
              gr.basic_block.__init__(self,
                  name="PDU to Hex Log File",
                  in_sig=None,
                  out_sig=None)

              self.filename = filename
              self.message_port_register_in(pmt.intern("in"))
              self.set_msg_handler(pmt.intern("in"), self.handle_msg)
              with open(self.filename, "w") as f:
                  f.write("-")
          def handle_msg(self, msg):
              if not pmt.is_pair(msg):
                  return

              meta = pmt.car(msg)
              data = pmt.cdr(msg)

              # Convert metadata to string
              meta_str = ""
              if pmt.is_dict(meta):
                  keys = pmt.dict_keys(meta)
                  for i in range(pmt.length(keys)):
                      key = pmt.symbol_to_string(pmt.nth(i, keys))
                      val = pmt.to_python(pmt.dict_ref(meta, pmt.intern(key), pmt.PMT_NIL))
                      meta_str += f"{key}={val}; "

              # Convert data to hex (for u8vector)
              if pmt.is_u8vector(data):
                  byte_array = bytearray(pmt.u8vector_elements(data))
                  data_str = byte_array.hex(" ")  # space-separated hex bytes
              elif pmt.is_f32vector(data):
                  data_list = pmt.f32vector_elements(data)
                  data_str = " ".join(f"{x:.6f}" for x in data_list)
              else:
                  data_str = str(pmt.to_python(data))

              # Timestamp
              timestamp = datetime.now().strftime("%Y-%m-%d %H:%M:%S.%f")

              with open(self.filename, "a") as f:
                  f.write(f"[time: {str(timestamp)}] meta: {str(meta_str)}| snr: {str(data_str)}\n")
    filename: '"snr.txt"'
    maxoutbuf: int(2e6)
  states: {}
- name: epy_block_7
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      import pmt
      from gnuradio import gr
      import time
      import threading

      class blk(gr.sync_block):
          def __init__(self, timeout=2.0):
              gr.sync_block.__init__(
                  self,
                  name="stall_phase_rotator_loop",
                  in_sig=[np.uint8],
                  out_sig=[np.uint8]
              )

              self.message_port_register_out(pmt.intern("phase_cmd"))

              # Parameters
              self.timeout = float(timeout)

              # State
              self.last_seen = time.time()
              self.last_sent = 0
              self.phase_index = 0
              self.last_phase_index = -1
              self.running = True
              self.lock = threading.Lock()

              # Start monitoring thread
              self._monitor_thread = threading.Thread(target=self._monitor, daemon=True)
              self._monitor_thread.start()

          def _monitor(self):
              while self.running:
                  now = time.time()
                  with self.lock:
                      time_since_flow = now - self.last_seen
                      time_since_sent = now - self.last_sent

                  if time_since_flow > self.timeout and time_since_sent > self.timeout:
                      with self.lock:
                          radians = (self.phase_index * np.pi / 2) % (2 * np.pi)
                          if self.phase_index != self.last_phase_index:
                              #print(f"[STALL] No input for {time_since_flow:.2f}s. Rotating: {radians:.2f} rad")
                              self.message_port_pub(pmt.intern("phase_cmd"), pmt.from_double(radians))
                              self.last_sent = now
                              self.last_phase_index = self.phase_index
                              self.phase_index = (self.phase_index + 1) % 4

                  time.sleep(self.timeout)

          def work(self, input_items, output_items):
              ninput = len(input_items[0])
              if ninput > 0:
                  with self.lock:
                      self.last_seen = time.time()
              output_items[0] = input_items[0]
              self.consume(0, ninput)
              return len(output_items)

          def stop(self):
              self.running = False
              return super().stop()
    timeout: '0.2'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    beta: '10'
    cutoff_freq: 5/12*device_rate
    decim: '1'
    gain: '1'
    maxoutbuf: int(2e6)
    samp_rate: device_rate
    type: fir_filter_fff
    width: 1/12*device_rate
    win: window.WIN_KAISER
  states: {}
- name: mmse_resampler_xx_2
  id: mmse_resampler_xx
  parameters:
    maxoutbuf: int(2e6)
    phase_shift: '0'
    resamp_ratio: device_rate/ (samp_rate/samp_per_sym/8*C.bits_per_symbol()*packet_len/(packet_len+12))
    type: float
  states: {}
- name: mmse_resampler_xx_2_0
  id: mmse_resampler_xx
  parameters:
    maxoutbuf: int(2e6)
    phase_shift: '0'
    resamp_ratio: ' (samp_rate/samp_per_sym/8*C.bits_per_symbol()*packet_len/(packet_len+12))/device_rate'
    type: float
  states: {}
- name: network_udp_sink_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '16'
    port: '5007'
    send_eof: 'False'
    type: float
  states: {state: disabled}
- name: network_udp_source_0
  id: network_udp_source
  parameters:
    comment: |-
      Constant source reads
      async messages from socket
    header: '0'
    ipv6: 'False'
    maxoutbuf: int(2e6)
    notify_missed: 'True'
    payloadsize: packet_len
    port: '5005'
    src_zeros: 'True'
    type: byte
  states: {}
- name: network_udp_source_1
  id: network_udp_source
  parameters:
    header: '0'
    ipv6: 'False'
    maxoutbuf: int(2e6)
    notify_missed: 'True'
    payloadsize: packet_len
    port: '5006'
    src_zeros: 'True'
    type: float
  states: {state: disabled}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: hackrf=1
    bb_gain0: '4'
    bw0: bandwidth
    clock_source0: internal
    comment: |-
      keep power very low to prevent
      spectra regrowth due to poor
      linearity of hackrf
    freq0: centerf
    gain0: '14'
    if_gain0: txgain
    maxoutbuf: int(2e6)
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: hackrf=0
    bb_gain0: rxgain
    comment: |-
      High gain is used with hackrf 
      on rx since the transmitter 
      is low power due to spectral
      regrowth
    corr0: ppm
    dc_offset_mode0: '1'
    freq0: centerf+shift
    gain0: '11'
    gain_mode0: 'True'
    if_gain0: rxgain
    maxoutbuf: int(2e6)
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: packetgen_0
  id: packetgen
  parameters:
    access_key: access_key
    comment: |-
      Create packet with header
      for tracking
    maxoutbuf: int(2e6)
    packet_len: packet_len
    packet_len_tagn: '"packet_len"'
  states: {}
- name: packetread_0
  id: packetread
  parameters:
    access_key: access_key
    maxoutbuf: int(2e6)
    packet_len: packet_len
    packet_len_tagn: '"packet_len"'
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: 3,0,1,1
    label1: RX
    label2: TX
    nconnections: '2'
    size: 1024*C.bits_per_symbol()
    type: complex
    update_time: '0.1'
  states: {}
- name: qtgui_eye_sink_x_0
  id: qtgui_eye_sink_x
  parameters:
    samp_per_symbol: '1'
    size: '1024'
    srate: samp_rate/samp_per_sym
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: device_rate
    color1: '"dark blue"'
    fc: '0'
    fftsize: '512'
    freqhalf: 'False'
    grid: 'True'
    name: '"Audio RX"'
    norm_window: 'True'
    type: float
    width1: '2'
    ymax: '0'
    ymin: '-100'
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_1
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    ctrlpanel: 'True'
    fc: centerf
    fftsize: '4096'
    grid: 'True'
    gui_hint: 3,1,1,1
    label1: '''RX'''
    label2: '''TX'''
    maxoutbuf: int(2e6)
    nconnections: '2'
    type: complex
    update_time: '0.05'
    wintype: window.WIN_RECTANGULAR
    ymax: '-20'
    ymin: '-80'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    gui_hint: 4,0,1,2
    name: '"RX"'
    size: '1024'
    srate: symbol_rate
    type: complex
    update_time: '0.1'
    ymax: '4'
    ymin: '-4'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    name: '"TX"'
    size: '1024'
    srate: symbol_rate
    type: complex
    update_time: '0.1'
    ymax: '4'
    ymin: '-4'
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate/samp_per_sym/8
    type: float
    ymax: '6.28'
    ymin: '-6.28'
  states: {state: disabled}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    color1: dark blue
    grid: 'True'
    name: '"Audio Rx"'
    size: '1024'
    srate: device_rate
    type: float
    width1: '2'
    ymax: '127'
    ymin: '-127'
  states: {state: disabled}
- name: rx_start_flag
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: satellites_rms_agc_0
  id: satellites_rms_agc
  parameters:
    alpha: '0.000001'
    maxoutbuf: int(2e6)
    reference: '0.5'
  states: {state: disabled}
- name: satellites_rms_agc_1
  id: satellites_rms_agc
  parameters:
    alpha: '0.000001'
    comment: |-
      0.000001 is this low 
      otherwise it cant receive
      large packets
    reference: '1'
  states: {}
- name: satellites_rms_agc_1_0
  id: satellites_rms_agc
  parameters:
    alpha: '0.00001'
    reference: '1'
  states: {}
- name: satellites_rms_agc_2
  id: satellites_rms_agc
  parameters:
    alpha: '0.00001'
    reference: '1'
  states: {}
- name: successpackets
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters: {}
  states: {state: disabled}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: rxfreq
  states: {}
- name: virtual_sink_10
  id: virtual_sink
  parameters:
    stream_id: txpktcounting
  states: {}
- name: virtual_sink_11
  id: virtual_sink
  parameters:
    stream_id: rxpktcounting
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: txfreq
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: idealconst
  states: {}
- name: virtual_sink_4
  id: virtual_sink
  parameters:
    stream_id: rxbytestream
  states: {}
- name: virtual_sink_5
  id: virtual_sink
  parameters:
    stream_id: rxtime
  states: {state: disabled}
- name: virtual_sink_6
  id: virtual_sink
  parameters:
    stream_id: rxconst
  states: {}
- name: virtual_sink_7
  id: virtual_sink
  parameters:
    stream_id: refbytestream
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters: {}
  states: {state: disabled}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: rxfreq
  states: {}
- name: virtual_source_10
  id: virtual_source
  parameters:
    stream_id: rxpktcounting
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: txfreq
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: idealconst
  states: {}
- name: virtual_source_4
  id: virtual_source
  parameters:
    stream_id: rxconst
  states: {}
- name: virtual_source_5
  id: virtual_source
  parameters:
    stream_id: rxtime
  states: {state: disabled}
- name: virtual_source_6
  id: virtual_source
  parameters:
    stream_id: txtime
  states: {state: disabled}
- name: virtual_source_8
  id: virtual_source
  parameters:
    stream_id: txpktcounting
  states: {}

connections:
- [analog_random_source_x_0, '0', blocks_selector_0_0, '2']
- [blocks_char_to_float_0_0, '0', mmse_resampler_xx_2_0, '0']
- [blocks_char_to_float_7, '0', epy_block_0, '0']
- [blocks_char_to_float_7_0, '0', epy_block_0_0, '0']
- [blocks_correctiq_0, '0', blocks_freqshift_cc_0, '0']
- [blocks_float_to_char_0, '0', blocks_selector_0_0, '1']
- [blocks_freqshift_cc_0, '0', const_demod_0, '0']
- [blocks_freqshift_cc_0, '0', satellites_rms_agc_1, '0']
- [blocks_multiply_const_vxx_0, '0', mmse_resampler_xx_2, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_throttle2_0, '0']
- [blocks_multiply_const_vxx_1, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_const_xx_0, '0', osmosdr_sink_0, '0']
- [blocks_multiply_const_xx_0, '0', virtual_sink_0, '0']
- [blocks_probe_rate_1, rate, blocks_message_debug_1, print]
- [blocks_selector_0, '0', epy_block_1, '0']
- [blocks_selector_0, '1', blocks_char_to_float_0_0, '0']
- [blocks_selector_0, '2', blocks_null_sink_0, '0']
- [blocks_selector_0_0, '0', packetgen_0, '0']
- [blocks_stream_to_tagged_stream_1, '0', virtual_sink_5, '0']
- [blocks_threshold_ff_0, '0', rx_start_flag, '0']
- [blocks_throttle2_0, '0', audio_sink_0, '0']
- [blocks_throttle2_0, '0', network_udp_sink_0, '0']
- [blocks_throttle2_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', packetread_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_throttle2_0_0, '0']
- [blocks_wavfile_source_0, '0', blocks_throttle2_0_0, '0']
- [const_demod_0, '0', epy_block_5, '0']
- [const_demod_0, '0', qtgui_eye_sink_x_0, '0']
- [const_demod_0, '0', qtgui_time_sink_x_1, '0']
- [const_demod_0, '0', virtual_sink_1, '0']
- [const_demod_0, '0', virtual_sink_4, '0']
- [const_demod_0, '1', packetread_0, '0']
- [const_demod_0, '2', virtual_sink_6, '0']
- [digital_constellation_modulator_0, '0', blocks_multiply_const_xx_0, '0']
- [digital_constellation_modulator_0, '0', satellites_rms_agc_0, '0']
- [digital_constellation_modulator_0, '0', virtual_sink_2, '0']
- [digital_constellation_modulator_0, '0', virtual_sink_3, '0']
- [digital_constellation_receiver_cb_0_0, '0', digital_diff_decoder_bb_0_1, '0']
- [digital_constellation_receiver_cb_0_0, '0', virtual_sink_4, '0']
- [digital_constellation_receiver_cb_0_0, '1', blocks_null_sink_1_1, '0']
- [digital_constellation_receiver_cb_0_0, '2', blocks_null_sink_1_1, '1']
- [digital_constellation_receiver_cb_0_0, '3', blocks_null_sink_1_1, '2']
- [digital_constellation_receiver_cb_0_0, '4', virtual_sink_6, '0']
- [digital_constellation_receiver_cb_0_0_0, '0', blocks_null_sink_4, '0']
- [digital_constellation_receiver_cb_0_0_0, '1', blocks_null_sink_1_1_0, '0']
- [digital_constellation_receiver_cb_0_0_0, '2', blocks_null_sink_1_1_0, '1']
- [digital_constellation_receiver_cb_0_0_0, '3', blocks_null_sink_1_1_0, '2']
- [digital_constellation_receiver_cb_0_0_0, '4', qtgui_const_sink_x_0, '1']
- [digital_diff_decoder_bb_0_1, '0', blocks_unpacked_to_packed_xx_0, '0']
- [digital_linear_equalizer_0, '0', satellites_rms_agc_1_0, '0']
- [digital_symbol_sync_xx_0_0, '0', digital_constellation_receiver_cb_0_0, '0']
- [digital_symbol_sync_xx_0_0_0, '0', digital_constellation_receiver_cb_0_0_0, '0']
- [epy_block_0, '0', blocks_file_sink_0_0_0, '0']
- [epy_block_0, '0', blocks_threshold_ff_0, '0']
- [epy_block_0, '0', successpackets, '0']
- [epy_block_0_0, '0', allpackets, '0']
- [epy_block_0_0, '0', blocks_file_sink_0_0, '0']
- [epy_block_1, out, epy_block_3, in]
- [epy_block_3, out, epy_block_4, msg_in]
- [epy_block_5, snr_out, blocks_message_debug_0, print]
- [epy_block_5, snr_out, epy_block_6, in]
- [epy_block_7, '0', blocks_null_sink_1_0, '0']
- [epy_block_7, phase_cmd, digital_constellation_receiver_cb_0_0, rotate_phase]
- [low_pass_filter_0, '0', blocks_multiply_const_vxx_1, '0']
- [low_pass_filter_0, '0', qtgui_time_sink_x_2, '0']
- [mmse_resampler_xx_2, '0', blocks_float_to_char_0, '0']
- [mmse_resampler_xx_2, '0', blocks_probe_rate_1, '0']
- [mmse_resampler_xx_2_0, '0', low_pass_filter_0, '0']
- [network_udp_source_0, '0', blocks_selector_0_0, '0']
- [network_udp_source_1, '0', blocks_throttle2_0_0, '0']
- [network_udp_source_1, '0', blocks_vector_to_stream_0, '0']
- [osmosdr_source_0, '0', blocks_correctiq_0, '0']
- [packetgen_0, '0', digital_constellation_modulator_0, '0']
- [packetgen_0, '0', epy_block_2, '0']
- [packetgen_0, '0', virtual_sink_10, '0']
- [packetgen_0, '0', virtual_sink_7, '0']
- [packetread_0, '0', blocks_selector_0, '0']
- [packetread_0, '0', epy_block_7, '0']
- [packetread_0, '0', virtual_sink_11, '0']
- [satellites_rms_agc_0, '0', osmosdr_sink_0, '0']
- [satellites_rms_agc_0, '0', virtual_sink_0, '0']
- [satellites_rms_agc_1, '0', digital_linear_equalizer_0, '0']
- [satellites_rms_agc_1, '0', epy_block_5, '0']
- [satellites_rms_agc_1, '0', qtgui_eye_sink_x_0, '0']
- [satellites_rms_agc_1, '0', virtual_sink_1, '0']
- [satellites_rms_agc_1_0, '0', digital_symbol_sync_xx_0_0, '0']
- [satellites_rms_agc_2, '0', digital_symbol_sync_xx_0_0_0, '0']
- [virtual_source_0, '0', const_demod_0, '0']
- [virtual_source_0, '0', satellites_rms_agc_1, '0']
- [virtual_source_1, '0', qtgui_freq_sink_x_0_1, '0']
- [virtual_source_10, '0', blocks_char_to_float_7, '0']
- [virtual_source_2, '0', qtgui_freq_sink_x_0_1, '1']
- [virtual_source_3, '0', satellites_rms_agc_2, '0']
- [virtual_source_4, '0', qtgui_const_sink_x_0, '0']
- [virtual_source_5, '0', qtgui_time_sink_x_0, '0']
- [virtual_source_6, '0', qtgui_time_sink_x_0_0, '0']
- [virtual_source_8, '0', blocks_char_to_float_7_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
