options:
  parameters:
    author: Eian
    generate_options: hb
    id: const_demod
    output_language: python
    title: Constellation Demodulator
  states: {}

blocks:
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(32, 32, 1.0/float(samp_per_sym), exbw, 11*samp_per_sym*32)
  states: {}
- name: rrctaps
  id: variable_rrc_filter_taps
  parameters:
    alpha: exbw
    gain: '32'
    ntaps: nfilt*samp_per_sym
    samp_rate: nfilt*samp_per_sym
    sym_rate: nfilt
  states: {}
- name: C
  id: parameter
  parameters:
    value: '[]'
  states: {}
- name: agc_alpha
  id: parameter
  parameters:
    label: AGC Alpha
    value: '0.001'
  states: {}
- name: agc_ref
  id: parameter
  parameters:
    label: AGC Ref
    value: '0.5'
  states: {}
- name: arity
  id: parameter
  parameters:
    label: arity
    value: '4'
  states: {}
- name: bits_per_symbol
  id: parameter
  parameters:
    label: Bits Per Symbol
    value: '0'
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    num_inputs: '3'
    type: float
  states: {}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: bits_per_symbol
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: const_slicer
  id: parameter
  parameters:
    label: TED Const Slicer
    value: '[]'
  states: {}
- name: digital_constellation_receiver_cb_0_0
  id: digital_constellation_receiver_cb
  parameters:
    comment: |-
      The receiver is the PLL
      It also acts as the constellation
      decoder
    constellation: C
    fmax: max_freq_dev
    fmin: min_freq_dev
    loop_bw: loop_bw
    showports: 'True'
  states: {}
- name: digital_diff_decoder_bb_0_1
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: arity
  states: {}
- name: digital_symbol_sync_xx_0_0
  id: digital_symbol_sync_xx
  parameters:
    comment: Timing sync and demod
    constellation: const_slicer
    damping: timing_damping
    loop_bw: timing_bw
    max_dev: '0.00000001'
    nfilters: '32'
    osps: '1'
    pfb_mf_taps: rrc_taps
    resamp_type: digital.IR_PFB_MF
    sps: samp_per_sym
    ted_gain: ted_gain
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: exbw
  id: parameter
  parameters:
    value: '0.35'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: loop_bw
  id: parameter
  parameters:
    label: Loop Bandwidth
    value: '0.0628'
  states: {}
- name: max_freq_dev
  id: parameter
  parameters:
    label: Max Freq Dev
    value: '0'
  states: {}
- name: min_freq_dev
  id: parameter
  parameters:
    label: Min_Freq_Dev
    value: '0'
  states: {}
- name: nfilt
  id: parameter
  parameters:
    label: Num Filters
    value: '128'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: fll_out
    type: complex
  states: {}
- name: pad_sink_2
  id: pad_sink
  parameters:
    label: symbol_out
    type: byte
  states: {}
- name: pad_sink_3
  id: pad_sink
  parameters:
    label: symbol_out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: pad_source_1
  id: pad_source
  parameters:
    label: in
    type: message
  states: {}
- name: samp_per_sym
  id: parameter
  parameters:
    value: '2'
  states: {}
- name: satellites_rms_agc_1
  id: satellites_rms_agc
  parameters:
    alpha: agc_alpha
    reference: agc_ref
  states: {}
- name: step_sz
  id: parameter
  parameters:
    label: Lin EQ Step Size
    value: '0'
  states: {}
- name: swidx
  id: parameter
  parameters:
    label: Switch Index (1 for 16 else 0)
    value: '0'
  states: {}
- name: ted_gain
  id: parameter
  parameters:
    label: TED Gain
    value: '0'
  states: {}
- name: timing_bw
  id: parameter
  parameters:
    label: Timing Bandwidth
    value: '0.045'
  states: {}
- name: timing_damping
  id: parameter
  parameters:
    label: Timing Damping
    value: '2'
  states: {}

connections:
- [blocks_unpacked_to_packed_xx_0, '0', pad_sink_2, '0']
- [digital_constellation_receiver_cb_0_0, '0', digital_diff_decoder_bb_0_1, '0']
- [digital_constellation_receiver_cb_0_0, '1', blocks_null_sink_1, '0']
- [digital_constellation_receiver_cb_0_0, '2', blocks_null_sink_1, '1']
- [digital_constellation_receiver_cb_0_0, '3', blocks_null_sink_1, '2']
- [digital_constellation_receiver_cb_0_0, '4', pad_sink_3, '0']
- [digital_diff_decoder_bb_0_1, '0', blocks_unpacked_to_packed_xx_0, '0']
- [digital_symbol_sync_xx_0_0, '0', digital_constellation_receiver_cb_0_0, '0']
- [pad_source_0, '0', satellites_rms_agc_1, '0']
- [pad_source_1, out, digital_constellation_receiver_cb_0_0, rotate_phase]
- [satellites_rms_agc_1, '0', digital_symbol_sync_xx_0_0, '0']
- [satellites_rms_agc_1, '0', pad_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
