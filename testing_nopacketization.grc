options:
  parameters:
    author: Eian
    generate_options: qt_gui
    id: testing_nopacketization
    output_language: python
    title: testing_nopacketization
  states: {}

blocks:
- name: C
  id: variable
  parameters:
    value: psk4
  states: {}
- name: aa
  id: variable_adaptive_algorithm
  parameters:
    cons: C
    modulus: C.arity()
    step_size: '0.0001'
    type: cma
  states: {}
- name: access_key
  id: variable
  parameters:
    value: '''11100001010110101110100010010011'''
  states: {}
- name: bandwidth
  id: variable
  parameters:
    value: symbol_rate*(1+exbw)
  states: {}
- name: centerf
  id: variable
  parameters:
    value: 0.912e9
  states: {}
- name: device_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: exbw
  id: variable
  parameters:
    value: '1'
  states: {}
- name: final_breath
  id: variable
  parameters:
    value: '"Final+Breath.wav"'
  states: {}
- name: hdr_format
  id: variable
  parameters:
    comment: header_format_default
    value: digital.header_format_default(access_key, 0)
  states: {}
- name: hunter
  id: variable
  parameters:
    value: '"Subtronics x Flowdan - Hunter.wav"'
  states: {}
- name: inputtype_sel
  id: variable
  parameters:
    value: music
  states: {}
- name: message
  id: variable
  parameters:
    value: '0'
  states: {}
- name: modulated_sync_word
  id: variable_modulate_vector
  parameters:
    data: '[225, 90, 232, 147, 1, 0, 1, 0]'
    mod: rxmod
    taps: '[1]'
  states: {}
- name: music
  id: variable
  parameters:
    value: '1'
  states: {}
- name: next_episode
  id: variable
  parameters:
    value: '"Dr. Dre - The Next Episode (Wooli Flip).wav"'
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: '128'
  states: {}
- name: port
  id: variable
  parameters:
    value: '5005'
  states: {}
- name: ppm
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1,1,1
    label: '"Tune PPM"'
    min_len: 20*10
    start: '-10'
    step: '0.1'
    stop: '10'
    value: '0.3'
    widget: counter
  states: {}
- name: psk2
  id: variable_constellation
  parameters:
    const_points: np.array([-1, 1])
    dims: '1'
    normalization: digital.constellation.NO_NORMALIZATION
    npwr: '2'
    precision: '16'
    rot_sym: '4'
    sym_map: '[0, 1]'
    type: calcdist
  states: {}
- name: psk4
  id: variable_constellation
  parameters:
    const_points: np.array([-4-4j, -4+4j, 4+4j, 4-4j])/4
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    npwr: '2'
    precision: '16'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    type: calcdist
  states: {}
- name: psk8
  id: variable_constellation
  parameters:
    const_points: np.array([-0.75+0.75j,-0.25-0.75j,0.75-0.75j, 0.25-0.75j,0.75-0.25j, 0.25-0.25j, -0.75-0.25j, -0.25-0.25j, 0.75+0.75j, 0.25+0.75j, -0.75-0.75j, -0.25+0.75j, -0.75+0.25j,-0.25+0.25j, 0.75+0.25j, 0.25+0.25j])/0.75
    npwr: '2'
    precision: '16'
    sym_map: list(range(16))
    type: 8psk
  states: {}
- name: qam16
  id: variable_constellation
  parameters:
    const_points: np.array([-0.75+0.75j,-0.25-0.75j,0.75-0.75j, 0.25-0.75j,0.75-0.25j, 0.25-0.25j, -0.75-0.25j, -0.25-0.25j, 0.75+0.75j, 0.25+0.75j, -0.75-0.75j, -0.25+0.75j, -0.75+0.25j,-0.25+0.25j, 0.75+0.25j, 0.25+0.25j])
    normalization: digital.constellation.NO_NORMALIZATION
    npwr: '2'
    precision: '16'
    sym_map: list(range(16))
    type: 16qam
  states: {}
- name: qam64
  id: variable_constellation
  parameters:
    const_points: np.array([-0.70711+-0.70711j, -0.50508+-0.70711j, -0.30304+-0.70711j, -0.10101+-0.70711j, 0.10101+-0.70711j, 0.30304+-0.70711j, 0.50508+-0.70711j, 0.70711+-0.70711j, -0.70711+-0.50508j, -0.50508+-0.50508j, -0.30304+-0.50508j, -0.10101+-0.50508j, 0.10101+-0.50508j, 0.30304+-0.50508j, 0.50508+-0.50508j, 0.70711+-0.50508j, -0.70711+-0.30304j, -0.50508+-0.30304j, -0.30304+-0.30304j, -0.10101+-0.30304j, 0.10101+-0.30304j, 0.30304+-0.30304j, 0.50508+-0.30304j, 0.70711+-0.30304j, -0.70711+-0.10101j, -0.50508+-0.10101j, -0.30304+-0.10101j, -0.10101+-0.10101j, 0.10101+-0.10101j, 0.30304+-0.10101j, 0.50508+-0.10101j, 0.70711+-0.10101j, -0.70711+0.10101j, -0.50508+0.10101j, -0.30304+0.10101j, -0.10101+0.10101j, 0.10101+0.10101j, 0.30304+0.10101j, 0.50508+0.10101j, 0.70711+0.10101j, -0.70711+0.30304j, -0.50508+0.30304j, -0.30304+0.30304j, -0.10101+0.30304j, 0.10101+0.30304j, 0.30304+0.30304j, 0.50508+0.30304j, 0.70711+0.30304j, -0.70711+0.50508j, -0.50508+0.50508j, -0.30304+0.50508j, -0.10101+0.50508j, 0.10101+0.50508j, 0.30304+0.50508j, 0.50508+0.50508j, 0.70711+0.50508j, -0.70711+0.70711j, -0.50508+0.70711j, -0.30304+0.70711j, -0.10101+0.70711j, 0.10101+0.70711j, 0.30304+0.70711j, 0.50508+0.70711j, 0.70711+0.70711j])/0.70711
    dims: '1'
    normalization: digital.constellation.NO_NORMALIZATION
    npwr: '2'
    precision: '16'
    rot_sym: '4'
    sym_map: list(range(64))
    type: calcdist
  states: {}
- name: qam8
  id: variable_constellation
  parameters:
    const_points: np.array([-1-1j, -1+1j, 1+1j, 1-1j, -0.67j, 0.67, 0.67j, -0.67])
    dims: '1'
    normalization: digital.constellation.NO_NORMALIZATION
    npwr: '2'
    precision: '16'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3, 4, 5 ,6 ,7]'
    type: calcdist
  states: {}
- name: random
  id: variable
  parameters:
    value: '2'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(128, 128, 1.0/float(samp_per_sym), exbw, 11*samp_per_sym*128)
  states: {}
- name: rxgain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: '"Receive Gain"'
    min_len: '8'
    start: '7'
    step: '1'
    stop: '40'
    value: '7'
    widget: counter
  states: {}
- name: rxmod
  id: variable
  parameters:
    value: digital.generic_mod(C, True, samp_per_sym, True, exbw, False, False)
  states: {}
- name: samp_per_sym
  id: variable
  parameters:
    value: '4'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: shift
  id: variable
  parameters:
    value: samp_rate/4
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: samp_rate/samp_per_sym
  states: {}
- name: txgain
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,1,1,1
    label: '"Transmit Gain"'
    min_len: '8'
    start: '0'
    step: '1'
    stop: '60'
    value: '42'
    widget: counter
  states: {}
- name: umm
  id: variable
  parameters:
    value: '"I Don''t Know.wav"'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    ok_to_block: 'False'
    samp_rate: int(device_rate)
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '2'
  states: {}
- name: blocks_char_to_float_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_message_debug_1
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 127*0.5
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/127
    type: float
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: '0.5'
    type: complex
  states: {}
- name: blocks_null_sink_1_1
  id: blocks_null_sink
  parameters:
    num_inputs: '3'
    type: float
  states: {}
- name: blocks_packed_to_unpacked_xx_0_0_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_probe_rate_1
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    maxoutbuf: int(2e6)
    mintime: '2000'
    type: float
  states: {}
- name: blocks_repack_bits_bb_1_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: packet_len
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    ignoretag: 'False'
    maxoutbuf: int(2e6)
    samples_per_second: device_rate
    type: float
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    ignoretag: 'False'
    maxoutbuf: int(2e6)
    samples_per_second: device_rate
    type: float
  states: {}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: C.bits_per_symbol()
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: '"music/Not In My Arms (Calibeats Remix)  Takara.mp3"'
    maxoutbuf: int(2e6)
    repeat: 'True'
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    comment: |-
      RRC pulse shaping
      and modulation in one
    constellation: C
    differential: 'True'
    excess_bw: exbw
    maxoutbuf: int(2e6)
    samples_per_symbol: samp_per_sym
  states: {}
- name: digital_constellation_receiver_cb_0_0
  id: digital_constellation_receiver_cb
  parameters:
    comment: |-
      The receiver is the PLL
      It also acts as the constellation
      decoder
      must have 0 deviation to get large packets
    constellation: C
    fmax: '0.7'
    fmin: '-0.7'
    loop_bw: 0.0628/8
    showports: 'True'
  states: {}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: ' '''''
    tagname: '"packet_len"'
    threshold: '0'
    type: byte
  states: {state: bypassed}
- name: digital_diff_decoder_bb_0_1
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: C.arity()
  states: {}
- name: digital_symbol_sync_xx_0_0
  id: digital_symbol_sync_xx
  parameters:
    comment: Timing sync and demod
    constellation: C.base()
    damping: '2'
    loop_bw: samp_rate/centerf*abs(ppm)/100
    max_dev: '0'
    nfilters: '128'
    osps: '1'
    pfb_mf_taps: rrc_taps
    resamp_type: digital.IR_PFB_MF
    sps: samp_per_sym
    ted_gain: '0.0001'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: mmse_resampler_xx_2
  id: mmse_resampler_xx
  parameters:
    maxoutbuf: int(2e6)
    phase_shift: '0'
    resamp_ratio: device_rate/ (samp_rate/samp_per_sym/8*C.bits_per_symbol())
    type: float
  states: {}
- name: mmse_resampler_xx_2_0
  id: mmse_resampler_xx
  parameters:
    maxoutbuf: int(2e6)
    phase_shift: '0'
    resamp_ratio: ' (samp_rate/samp_per_sym/8*C.bits_per_symbol())/device_rate'
    type: float
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: 3,0,1,1
    label1: RX
    size: 1024*C.bits_per_symbol()
    type: complex
    update_time: '0.1'
  states: {}
- name: qtgui_freq_sink_x_0_1
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    ctrlpanel: 'True'
    fc: centerf
    fftsize: '4096'
    grid: 'True'
    gui_hint: 3,1,1,1
    label1: '''RX'''
    label2: '''TX'''
    maxoutbuf: int(2e6)
    nconnections: '2'
    type: complex
    update_time: '0.05'
    wintype: window.WIN_RECTANGULAR
    ymax: '-20'
    ymin: '-80'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    gui_hint: 4,0,1,2
    name: '"RX"'
    size: '1024'
    srate: symbol_rate
    type: complex
    update_time: '0.1'
    ymax: '4'
    ymin: '-4'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    name: '"TX"'
    size: '1024'
    srate: symbol_rate
    type: complex
    update_time: '0.1'
    ymax: '4'
    ymin: '-4'
  states: {state: disabled}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    color1: dark blue
    grid: 'True'
    name: '"Audio Rx"'
    nconnections: '2'
    size: '1024'
    srate: device_rate
    type: float
    width1: '2'
    ymax: '127'
    ymin: '-127'
  states: {}
- name: satellites_rms_agc_1
  id: satellites_rms_agc
  parameters:
    alpha: '0.000001'
    comment: |-
      0.000001 is this low 
      otherwise it cant receive
      large packets
    reference: '0.95'
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters: {}
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: rxfreq
  states: {}
- name: virtual_sink_10
  id: virtual_sink
  parameters:
    stream_id: txpktcounting
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: txfreq
  states: {}
- name: virtual_sink_4
  id: virtual_sink
  parameters:
    stream_id: rxbytestream
  states: {}
- name: virtual_sink_6
  id: virtual_sink
  parameters:
    stream_id: rxconst
  states: {}
- name: virtual_sink_7
  id: virtual_sink
  parameters:
    stream_id: refbytestream
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters: {}
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: rxfreq
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: txfreq
  states: {}
- name: virtual_source_4
  id: virtual_source
  parameters:
    stream_id: rxconst
  states: {}
- name: virtual_source_5
  id: virtual_source
  parameters:
    stream_id: rxtime
  states: {state: disabled}
- name: virtual_source_6
  id: virtual_source
  parameters:
    stream_id: txtime
  states: {state: disabled}

connections:
- [blocks_char_to_float_0_0, '0', mmse_resampler_xx_2_0, '0']
- [blocks_char_to_float_0_0, '0', qtgui_time_sink_x_2, '0']
- [blocks_char_to_float_1, '0', qtgui_time_sink_x_2, '1']
- [blocks_float_to_char_0, '0', blocks_char_to_float_1, '0']
- [blocks_float_to_char_0, '0', digital_constellation_modulator_0, '0']
- [blocks_float_to_char_0, '0', virtual_sink_10, '0']
- [blocks_float_to_char_0, '0', virtual_sink_7, '0']
- [blocks_multiply_const_vxx_0, '0', mmse_resampler_xx_2, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_throttle2_0, '0']
- [blocks_multiply_const_xx_0, '0', virtual_sink_0, '0']
- [blocks_packed_to_unpacked_xx_0_0_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_probe_rate_1, rate, blocks_message_debug_1, print]
- [blocks_repack_bits_bb_1_0, '0', blocks_char_to_float_0_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', digital_correlate_access_code_xx_ts_0, '0']
- [blocks_throttle2_0, '0', audio_sink_0, '0']
- [blocks_throttle2_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', blocks_packed_to_unpacked_xx_0_0_0, '0']
- [blocks_wavfile_source_0, '0', blocks_probe_rate_1, '0']
- [blocks_wavfile_source_0, '0', blocks_throttle2_0_0, '0']
- [digital_constellation_modulator_0, '0', blocks_multiply_const_xx_0, '0']
- [digital_constellation_modulator_0, '0', virtual_sink_2, '0']
- [digital_constellation_receiver_cb_0_0, '0', digital_diff_decoder_bb_0_1, '0']
- [digital_constellation_receiver_cb_0_0, '0', virtual_sink_4, '0']
- [digital_constellation_receiver_cb_0_0, '1', blocks_null_sink_1_1, '0']
- [digital_constellation_receiver_cb_0_0, '2', blocks_null_sink_1_1, '1']
- [digital_constellation_receiver_cb_0_0, '3', blocks_null_sink_1_1, '2']
- [digital_constellation_receiver_cb_0_0, '4', virtual_sink_6, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_repack_bits_bb_1_0, '0']
- [digital_diff_decoder_bb_0_1, '0', blocks_unpacked_to_packed_xx_0, '0']
- [digital_symbol_sync_xx_0_0, '0', digital_constellation_receiver_cb_0_0, '0']
- [mmse_resampler_xx_2, '0', blocks_float_to_char_0, '0']
- [mmse_resampler_xx_2_0, '0', blocks_multiply_const_vxx_1, '0']
- [satellites_rms_agc_1, '0', digital_symbol_sync_xx_0_0, '0']
- [satellites_rms_agc_1, '0', virtual_sink_1, '0']
- [virtual_source_0, '0', digital_symbol_sync_xx_0_0, '0']
- [virtual_source_0, '0', satellites_rms_agc_1, '0']
- [virtual_source_0, '0', virtual_sink_1, '0']
- [virtual_source_1, '0', qtgui_freq_sink_x_0_1, '0']
- [virtual_source_2, '0', qtgui_freq_sink_x_0_1, '1']
- [virtual_source_4, '0', qtgui_const_sink_x_0, '0']
- [virtual_source_5, '0', qtgui_time_sink_x_0, '0']
- [virtual_source_6, '0', qtgui_time_sink_x_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
